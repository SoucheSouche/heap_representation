## sdkconfig.defaults
```kconfig
CONFIG_ESP_INT_WDT=n
CONFIG_ESP_TASK_WDT_EN=n
CONFIG_HEAP_TASK_TRACKING=n
CONFIG_HEAP_ABORT_WHEN_ALLOCATION_FAILS=n
```
